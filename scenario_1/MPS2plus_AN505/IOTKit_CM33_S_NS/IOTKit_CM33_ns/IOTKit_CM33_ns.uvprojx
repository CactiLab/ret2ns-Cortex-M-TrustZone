# Keil uVision project IOTKit_CM33_ns.uvprojx, settings and files
target V2M-MPS2+ (6150000::V6.15::ARMCLANG)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.4.2
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28200000,0x00200000) IROM(0x10000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: IOTKit_CM33_ns
  c flags: Optim=7 OneElfS=1 v6Lang=5
  c include: .\
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  group Source Group 1
    ./: main_ns.c
  group CMSE Library
    ../IOTKit_CM33_s/: Secure_Functions.h
    ../IOTKit_CM33_s/Objects/: IOTKit_CM33_s_CMSE_Lib.o
  group Documentation
    ../: Abstract.txt
software components: CMSIS:CORE 5.0.0, Board Support:Common 2.0.0, Board Support:LED 2.0.0, Device:Startup 1.0.0
